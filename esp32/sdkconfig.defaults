## esp32/sdkconfig.defaults
```kconfig
# Ajustes base recomendados para desarrollo
CONFIG_ESPTOOLPY_FLASHSIZE_4MB=y
CONFIG_PARTITION_TABLE_SINGLE_APP=y
CONFIG_PARTITION_TABLE_OFFSET=0x8000
```
